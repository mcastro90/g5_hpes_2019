SUMMARY = "A console-only image that fully supports the target device \
hardware."
LICENSE = "MIT"

require images/console-image.bb

export IMAGE_BASENAME = "tec-image"
